## esp32-mqtt5/sdkconfig.defaults
```kconfig
CONFIG_MQTT_PROTOCOL_5=y
CONFIG_EXAMPLE_WIFI_SSID="Nha Mr Duc"
CONFIG_EXAMPLE_WIFI_PASSWORD="0901111488"
```
